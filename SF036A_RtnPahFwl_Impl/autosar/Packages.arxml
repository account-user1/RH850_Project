<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="766633B8-BF9E-4B5E-B630-42C16A649966">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="227487D7-498C-44D9-94A9-F7E489F2D6F9">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FE870CD6-1B07-48CC-A33D-979C20DBE100">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7182F3E4-50B7-4F5E-A37C-C1F31AF25970">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="14A86560-A4A9-48AC-AEBF-975DF2BB4C47">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="206ADB1D-2AFB-4857-A11D-653C5352D0AD">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="42FBE814-6A6B-426A-9F94-9EC157A9352D">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="99FD5429-5806-4EA1-858E-83B511F58EBC">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="07C1D062-618B-4EBE-9BC1-4EF956A1E0C2">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A8266B37-91D0-4FD2-8FBA-A26DD0FA83D0">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3CD8CE50-C3EA-481C-A3A4-CCE1D8C86677">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="545F0A4E-8CAC-4330-994E-2C09B2B85133">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8F20CC77-E2DB-416D-92C6-9E3B98F2B904">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C89297C3-44DE-4830-BD97-16AE8CD204B5">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="09FD7AAA-0509-45AB-96DC-F2283ED1B364">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="12DC10A0-B0D1-46BD-B9C5-8C1724B462E1">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="858A192C-7719-4049-AB07-5E14B8589118">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DF9CDDC3-102A-4283-A461-40C1E95FD26E">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="869B7B07-52C9-4661-BD35-747C27731B63">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="62A31D46-E813-44DC-9A1C-03F931C287CD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F5BC336D-7F68-431F-A132-1C9964947D8C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="69008EEE-C7E6-4D44-B2DF-22752EB17695">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6129620B-B6E6-4A91-8F1B-96DD4AEADBB0">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D5B4E095-8F3D-418F-AB06-BD30490B5310">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B9DA3936-0616-4462-860B-CCADE2347CEF">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FA3ECD6F-8AD4-4EC1-B91D-9568DD6557C3">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>