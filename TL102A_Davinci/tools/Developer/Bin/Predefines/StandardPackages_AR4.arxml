<?xml version="1.0" encoding="utf-8"?>
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
	<AR-PACKAGES>
		<AR-PACKAGE>
			<SHORT-NAME>ComponentTypes</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE>
					<SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>ConstantMappingSets</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>Constants</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>DataTypes</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE>
					<SHORT-NAME>BaseTypes</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>CompuMethods</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>DataConstrs</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>Units</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ECUCompositions</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>EndToEndProtections</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ModeDclrGroups</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>PortInterfaces</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>Systems</SHORT-NAME>
		</AR-PACKAGE>
        <AR-PACKAGE>
            <SHORT-NAME>Blueprints</SHORT-NAME>
            <AR-PACKAGES>
                <AR-PACKAGE>
                    <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE>
                    <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
                </AR-PACKAGE>
            </AR-PACKAGES>
        </AR-PACKAGE>
    </AR-PACKAGES>
</AUTOSAR>
