<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="BA97744E-166D-4CDB-9A05-624EE30422A3">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B72FC302-5109-4A73-BFDA-23518191E4F3">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A5EA66E3-EBA9-404D-87A9-FCCEF8C752A2">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EA0C5E39-2300-4367-A628-AACDBE2F3A73">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0EAE604A-7A50-4B46-B863-3919C7C1E5FF">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2BA811B7-4329-465E-9399-760119FBEC9D">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B43FBBE7-3841-4BB2-BF2E-35688F8E31B5">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="09AAEE65-BD37-4592-A975-669D43712757">
      <SHORT-NAME>DataDictionary</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1FF23ACE-302D-45EA-AD46-D22AD67B60C1">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="1E157B91-D97D-472F-9015-26F8909C72E7">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C7F47AA8-4041-49F7-8D4C-17A439447A7A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D9D08631-FF65-4555-BF0E-57AEF4546B9C">
          <SHORT-NAME>DataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A53F213A-2BA7-418A-A4E5-B88E4ABFE9C3">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7B30A655-D959-4A4C-9955-B9EF5682F090">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3A922657-D982-42EC-A46F-87FF4BB9E579">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="99DC897B-5A84-4B70-9BB2-450B544F1888">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="403EA838-B038-49A6-B7A0-35195068FF5E">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8E27308D-9F07-4805-9511-38A77229D670">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="08687913-C7D4-4222-9619-4013C70CBB38">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BAD5F4CF-A933-40EE-849A-D5D51AAD151D">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="61FD91A7-9255-42EE-A1AE-4C24D5B32F65">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB9B97D4-62DF-4855-9FBD-FE2B516C4113">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="54B76D2C-DE91-4719-9EB3-5C0672A5015F">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="398CB280-7295-4A24-8FF2-4CC37F5ABF70">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B68E5CB1-51EA-49F1-A760-194C4284A925">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1F4A8601-221C-441D-A3E0-46B8B301C548">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="172FE4F3-EA35-46A2-AF59-FBC3B0B8762D">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E9AF220A-8809-4FA1-895B-93830190844F">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A5BF466-E37D-4204-B192-B304D1A687FC">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3D0CB0C6-5ECC-4992-9EF6-0031BCB78EC4">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>