<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="71748D18-5AD6-4612-8701-52265894F117">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5B358521-71D7-432F-B582-6B38EC345CA4">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="88C271C1-8BF6-4CB1-A531-6CCF3317DC04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7AFB0263-66DF-4244-BCBD-2D926E7C8C35">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="300810AB-6673-4712-A01A-378A5B2315E6">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6B77E57D-2C9F-443A-ACAD-3AC681B04F41">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5973249F-9076-474C-A3A4-C466F4376F37">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AFBBDEE0-0827-49D0-B354-F1E62CAADACF">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="55873589-E0EE-403C-BE51-2DD3B5B55953">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6B49A8D-2381-44BA-B800-287FF63CED2E">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="724F61EC-1404-4369-BD78-CC7DF8F21376">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D696BFEA-50C5-45C2-B3CB-52579CDDB1D6">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="81921ABE-717A-4504-A384-5E28E8CC33F0">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1C9DB839-D710-4DDD-81EB-082B473FFE7B">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="44D2635A-1873-4CA1-9257-B468B14BAD99">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E4994FC5-3606-4713-B47E-E9B2AD0242D7">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBC2479-D585-4F8F-8CFB-F408DDE17CA0">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7FBB2E0A-B5B0-454F-8C64-C01A7C23CD8B">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AB15681F-F7E2-4301-86FA-9019F9759B2C">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4A623C62-0F7A-41FE-98EF-3877C757A0DE">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EAA1D10F-D085-42BF-A063-7A18FDB43B6A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9EC97662-7F8F-4E3B-A38A-2B7B4475BF94">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2605ED41-2EF5-436C-AC66-BA5B247E2E5D">
      <SHORT-NAME>Nexteer</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="40FA8A58-D827-43FB-9CAA-6566A343F97B">
          <SHORT-NAME>Calibrations</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6EED526-EB9C-43E7-948E-327109E2467B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A96F0713-E97F-4677-BDA9-B2836A0CF99E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FAE209C7-EE78-43C1-8EFC-CC40C4974A61">
          <SHORT-NAME>DataTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="172B6DD5-F18F-4595-BAB7-F2215C69DE97">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3FBE749B-791D-450A-9722-1F08493F5E19">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E93F6EFF-381F-456B-9B7F-EC0F9F7B7687">
          <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3127C774-147F-4405-A717-2DDF67A6659E">
          <SHORT-NAME>NvMProxy_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E95BF695-CA46-44DA-835A-05D94B642589">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E6F1D64C-AE3C-41CC-9F2D-57BA63C7C318">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B6E9B75E-F1E2-42CE-8D7C-F623CA410CAE">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="43A9C058-AD38-4EBE-82C6-24E2C3C34DA3">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="04B50E28-379E-4CAF-800E-742E155EAAB2">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0B37E90B-DDF1-4003-A5EC-97F40355B5B6">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ADF49445-DAA0-49FC-9907-7399153DE330">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F9105805-AE0F-4741-98DA-AC3309A91548">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7C93988E-0450-4FB4-A1EC-DABBE6247237">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1C204E04-C1F1-4323-824D-EC34939081C4">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>