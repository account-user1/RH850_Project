<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xsi:schemaLocation="http://autosar.org/3.2.1 autosar_321.xsd" xmlns="http://autosar.org/3.2.1" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
	<TOP-LEVEL-PACKAGES>
		<AR-PACKAGE>
			<SHORT-NAME>ComponentType</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>Constant</SHORT-NAME>
		</AR-PACKAGE>
			<AR-PACKAGE>
			<SHORT-NAME>DataType</SHORT-NAME>
			<SUB-PACKAGES>
				<AR-PACKAGE>
					<SHORT-NAME>DataTypeSemantics</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>DataTypeUnits</SHORT-NAME>
				</AR-PACKAGE>
			</SUB-PACKAGES>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ECUComposition</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ECUCompositionType</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>EndToEndProtection</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>ModeDclrGroup</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>PortInterface</SHORT-NAME>
		</AR-PACKAGE>
		<AR-PACKAGE>
			<SHORT-NAME>VehicleProject</SHORT-NAME>
		</AR-PACKAGE>
	</TOP-LEVEL-PACKAGES>
</AUTOSAR>
