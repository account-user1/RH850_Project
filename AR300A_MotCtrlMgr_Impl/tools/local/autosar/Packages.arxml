<?xml version="1.0" encoding="utf-8"?>
<!--
This file was saved with a tool from Vector Informatik GmbH
-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="5B6599FB-B013-4F46-B741-41E07FDAB079">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="154491D2-36A9-41CC-9C0B-ADF69D7816F4">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1155A995-59BE-4CA3-8D55-C06D0203B439">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1F79A08C-C743-4A74-B02D-5EB6D4E159FD">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A961DD62-FDC0-43AD-9BEB-07E22CC9BAA0">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FF855674-10A5-44BC-9C00-4292DE7D3A95">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4150C402-40AE-4243-9AB4-204CF54C5237">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C32182B7-57A1-4319-9B26-29E0FB22759F">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A65A788F-E536-4A44-8682-2E85CE24A73A">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C373AF81-9C48-44AC-BFAF-3E89178D3C0D">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BAFFB73F-3A0E-46BD-AAEA-D71CFB280073">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="85DEEBFC-FABB-4651-960F-4257FEC44353">
          <SHORT-NAME>PlatformTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6D2EA40A-52E4-4926-BEEF-051A55F10A41">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E27D578C-0604-4D91-9FEC-0C04CC3BC621">
      <SHORT-NAME>DaVinci</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="29AAD423-EA4D-4B2D-BCEC-6C5C375AE418">
          <SHORT-NAME>PKG_ECU</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3F79171A-40A9-49A4-ACD7-926A74614FB5">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B90B3DE0-D719-4E1D-AE16-CDF790A34CE9">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5148B361-0AEA-48BC-B59E-BF1145BD3BAB">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="32C9C433-5C8B-4587-B550-D283083C6C5C">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D00084B0-B232-45EC-A402-255177B681BC">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3BA27B17-72C0-4BD9-82F1-A48A49A97321">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>